# IAR project Backup of Concentrator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\CMSIS\Device\STM32F10x\Include; ..\..\..\STM32F10x_StdPeriph_Driver\inc; ..\..\LIB\STM32F10x_StdPeriph_Driver\inc; ..\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Concentrator.hex
  ILINK.IlinkOutputFile: Concentrator.out
  ILINK.IlinkIcfFile: Concentrator.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../../APP/src/: Appcon_API.c EquipMgmt.c GPRS.c MCPX.c ReadEquipData.c
  group BSP
    ../../BSP/scr/: CH376T.c DriverPcb.c ENC28J60.c IICEeprom_24CXX.c MCU_Config.c MG2618.c PCF8563.c PowercConfig.c SerialPort.c W25QXX.c
  group LIB/FAT
    ../../LIB/FAT/: diskio.c ff.c
  group LIB/FLT
    ../../LIB/FLT/: filter.c
  group LIB/STM32F10X/CMSIS
    ../../LIB/CMSIS/Device/STM32F10x/Source/Templates/iar/: startup_stm32f10x_hd.s
  group LIB/STM32F10X/STM32F10x_StdPeriph_Driver
    ../../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Project
    ../src/: Common_API.c main.c SofTimer.c stm32_it.c system_stm32f10x.c
  group SPCP/JINGDA
    ../../SPCP/JingDa/: JINGDA.c
  group SPCP/APPCON
    ../../SPCP/APPCON/: APPCON.c
  group SPCP/CJT-188-2004
    ../../SPCP/CJT-188-2004/: CJT-188-2004.c
  group SPCP/DLT 645-1997
    ../../SPCP/DLT 645-1997/: DLT 645-1997.c
  group SPCP/KingDa
    ../../SPCP/KingDa/: CRC8.C KingDaServer.c KingDaV1.c
  group SPCP/ModBus
    ../../SPCP/ModBus/: Modbus_master.c modbus_slave.c
